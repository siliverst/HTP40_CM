# Keil uVision project HTP40_CMS.uvproj, settings and files
target HTP40_CMS (MCS-51)
  device: CMS80F231x Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: HTP40_CMS +hex
  c flags: Optimize=12 SizeSpeed=1
  group Source
    ./: pin_manager.c pin_manager.h main.c globalvar.h typedefs.h globalvar.c service_timing.c service_timing.h STARTUP.A51 uart.c uart.h uart_proc.c uart_proc.h measuring.c measuring.h trim.c trim.h switch_flags.c switch_flags.h NTC.c NTC.h led_sf.c led_sf.h mk.c mk.h fan.c fan.h test_auto.c test_auto.h lamp.c lamp.h door_sensor.c door_sensor.h eeprom.c eeprom.h sound.c sound.h
